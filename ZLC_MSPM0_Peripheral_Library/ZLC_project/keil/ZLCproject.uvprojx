# Keil uVision project ZLCproject.uvprojx, settings and files
target ZLC_MSPM0G3507 (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20200000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ZLCproject +hex
  BeforeMake: cmd.exe /C "$P../../tools/keil/syscfg.bat '$P' ZLCproject.syscfg"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\..\source\third_party\CMSIS\Core\Include;..\..\source;..\BSP;..\;..\zf_common;..\zf_device;..\zf_driver;..\ZLC_lib
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group Main
    ../: board.c board.h ti_msp_dl_config.c ti_msp_dl_config.h main.c ZLCproject.syscfg
    ./: startup_mspm0g350x_uvision.s
  group Driverlib
    ../ti/: dl_vref.c dl_uart.c dl_trng.c dl_timer.c dl_spi.c dl_rtc_common.c dl_opa.c dl_mcan.c dl_mathacl.c dl_lfss.c dl_lcd.c dl_keystorectl.c dl_i2c.c dl_flashctl.c dl_dma.c dl_dac12.c dl_crcp.c dl_crc.c dl_common.c dl_aesadv.c dl_aes.c dl_adc12.c
  group zf_common
    ../zf_common/: zf_common_debug.c zf_common_debug.h zf_common_function.c zf_common_function.h zf_common_typedef.h
  group zf_device
    ../zf_device/: zf_device_imu_interface.c zf_device_imu_interface.h zf_device_imu660ra.c zf_device_imu660ra.h
  group ZLC_lib
    ../ZLC_lib/: ZLC_poseCalculate.c ZLC_poseCalculate.h ZLC_Servo.c ZLC_Servo.h ZLC_Motor.c ZLC_Motor.h ZLC_Encoder.c ZLC_Encoder.h ZLC_PID.c ZLC_PID.h ZLC_GPIO_Peripheral.c ZLC_GPIO_Peripheral.h ZLC_Navigation.c ZLC_Navigation.h ZLC_Key.c ZLC_Key.h ZLC_QuestionTask.c ZLC_QuestionTask.h ZLC_headfile.h
